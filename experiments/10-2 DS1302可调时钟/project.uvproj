# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\..\common
  group Source Group 1
    ./: main.c
    ../../common/: timer0.c LCD1602.c key.c DS1302.c delay.c timer0.h LCD1602.h key.h DS1302.h delay.h
