# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c delay.c DS18B20.c LCD1602.c onewire.c delay.h DS18B20.h LCD1602.h onewire.h AT24C02.h I2C.h key.h AT24C02.c I2C.c key.c timer0.c timer0.h
