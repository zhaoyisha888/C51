# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\..\common
  group Source Group 1
    ./: main.c
    ../../common/: buzzer.h buzzer.c timer0.c delay.c timer0.h delay.h
