# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: main.c delay.h key.h nixie.h timer0.h delay.c key.c nixie.c timer0.c AT24C02.c I2C.c AT24C02.h I2C.h
