# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c delay.c Int0.c IR.c motor.c nixie.c timer0.c timer1.c delay.h Int0.h IR.h motor.h nixie.h timer0.h timer1.h
